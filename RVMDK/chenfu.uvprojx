# Keil uVision project chenfu.uvprojx, settings and files
target chenfu (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD103 +hex
  AfterMake: fromelf --bin --output @L.bin "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_MD
  c include: ..\Library;..\Library\CMSIS;..\Library\CMSIS\GD;..\Library\CMSIS\GD\GD32F10x;..\Library\CMSIS\GD\GD32F10x\Include;..\Library\CMSIS\GD\GD32F10x\Source;..\Library\CMSIS\GD\GD32F10x\Source\ARM;..\Library\Standard\Include;..\Library\Standard\Source;..\User;..\User\common;..\User\port;..\User\port\gpio;..\User\port\sysTick;..\User\port\usart\usart1;..\User\port\usart;..\User\port\usart\usart2;..\User\port\can\can0;..\User\port\can;..\User\bms;..\User\charger;..\User\pro\modbus;..\User\ctr_sub
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../User/: gd32f10x_libopt.h includes.h main.c bsp.c bsp.h
  group library
    ../Library/Standard/Source/: gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_usart.c gd32f10x_dma.c gd32f10x_can.c gd32f10x_dbg.c
  group startup
    ../Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
    ../Library/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group common
    ../User/common/: type.h debug_printf.c debug_printf.h common.c common.h
  group port
    ../User/port/gpio/: gpio.c gpio.h
    ../User/port/sysTick/: sysTick.c sysTick.h
    ../User/port/usart/usart1/: usart1.c usart1.h
    ../User/port/usart/: usart.c usart.h
    ../User/port/usart/usart2/: usart2.c usart2.h
    ../User/port/can/can0/: can0.c can0.h
    ../User/port/can/: can.c can.h
  group bms
    ../User/bms/: lowerlayer_Bms.c lowerlayer_Bms.h lowerlayer_BmsInfo.c lowerlayer_BmsInfo.h
  group charger
    ../User/charger/: zy_Charger.c zy_Charger.h zy_ChargerInfo.c zy_ChargerInfo.h
  group pro
    ../User/pro/modbus/: modbus_Pro.c modbus_Pro.h
  group ctr_sub
    ../User/ctr_sub/: upperlayer.c upperlayer.h upperlayer_stateInfo.c upperlayer_stateInfo.h upperlayer_cfgInfo.c upperlayer_cfgInfo.h
software components: CMSIS:CORE 5.1.2
